# IAR project WaterCounter.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; $ZSTACKDIR$\Projects\zstack\HomeAutomation\Source; $ZSTACKDIR$\Projects\zstack\ZMain\TI2530DB; ..\hal\include; ..\hal\target\CC2530DEV; $ZSTACKDIR$\Components\mac\include; $ZSTACKDIR$\Components\mac\high_level; $ZSTACKDIR$\Components\mac\low_level\srf04; $ZSTACKDIR$\Components\mac\low_level\srf04\single_chip; $ZSTACKDIR$\Components\mt; $ZSTACKDIR$\Components\osal\include; $ZSTACKDIR$\Components\services\saddr; $ZSTACKDIR$\Components\services\sdata; $ZSTACKDIR$\Components\stack\af; $ZSTACKDIR$\Components\stack\bdb; $ZSTACKDIR$\Components\stack\gp; $ZSTACKDIR$\Components\stack\nwk; $ZSTACKDIR$\Components\stack\sapi; $ZSTACKDIR$\Components\stack\sec; $ZSTACKDIR$\Components\stack\sys; $ZSTACKDIR$\Components\stack\zcl; $ZSTACKDIR$\Components\stack\zdo; $ZSTACKDIR$\Components\zmac; $ZSTACKDIR$\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $ZSTACKDIR$\Projects\zstack\Tools\CC2530DB\f8w2530.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: DEFAULT_CHANLIST=0x07FFF800; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; ZTOOL_P2; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_DEBUG_FUNC; MT_ZDO_FUNC; MT_ZDO_MGMT; MT_APP_CNF_FUNC; xLCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; HAL_LCD=FALSE; HAL_LED3_ENABLE; HAL_LED4_ENABLE; HAL_LED5_ENABLE; HAL_PUSH1_ENABLE; LED_POLARITY=ACTIVE_LOW; PUSH_POLARITY=ACTIVE_LOW; ISR_KEYINTERRUPT; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; xZCL_ON_OFF; ZCL_GROUPS; ZCL_REPORT; ZCL_TIME; ZCL_POWER_CONFIG; ZCL_ALARMS; BDB_REPORTING
configuration EndDeviceEB - OTAClient (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; xLCD_SUPPORTED=DEBUG; HAL_LCD=FALSE; HAL_LED3_ENABLE; HAL_LED4_ENABLE; HAL_LED5_ENABLE; HAL_PUSH1_ENABLE; LED_POLARITY=ACTIVE_LOW; PUSH_POLARITY=ACTIVE_LOW; ISR_KEYINTERRUPT; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; xZCL_ON_OFF; ZCL_GROUPS; ZCL_REPORT; ZCL_TIME; ZCL_POWER_CONFIG; ZCL_ALARMS; OTA_CLIENT=TRUE; OTA_HA; BDB_REPORTING
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; $ZSTACKDIR$\Projects\zstack\HomeAutomation\Source; $ZSTACKDIR$\Projects\zstack\ZMain\TI2530DB; ..\hal\include; ..\hal\target\CC2530DEV; $ZSTACKDIR$\Components\mac\include; $ZSTACKDIR$\Components\mac\high_level; $ZSTACKDIR$\Components\mac\low_level\srf04; $ZSTACKDIR$\Components\mac\low_level\srf04\single_chip; $ZSTACKDIR$\Components\mt; $ZSTACKDIR$\Components\osal\include; $ZSTACKDIR$\Components\services\saddr; $ZSTACKDIR$\Components\services\sdata; $ZSTACKDIR$\Components\stack\af; $ZSTACKDIR$\Components\stack\bdb; $ZSTACKDIR$\Components\stack\gp; $ZSTACKDIR$\Components\stack\nwk; $ZSTACKDIR$\Components\stack\sapi; $ZSTACKDIR$\Components\stack\sec; $ZSTACKDIR$\Components\stack\sys; $ZSTACKDIR$\Components\stack\zcl; $ZSTACKDIR$\Components\stack\zdo; $ZSTACKDIR$\Components\zmac; $ZSTACKDIR$\Components\zmac\f8w; $ZSTACKDIR$\Projects\zstack\OTA\Source
  postbuild: "$ZSTACKDIR$\Projects\tools\OTA\OtaConverter\Release\OtaConverter.exe" "EndDeviceEB - OTAClient\Exe\EndDeviceEB-OTAClient.sim" -o"EndDeviceEB - OTAClient\Exe" -t0x1234 -m0x5678 -v0000ABCD -pCC2530DB
  XLINK.XclFile: $ZSTACKDIR$\Projects\zstack\Tools\CC2530DB\ota.xcl
configuration RouterEB - OTAClient (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_ZDO_MGMT; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; OTA_CLIENT=TRUE; OTA_HA; ZCL_GROUPS
  ICC8051.CCIncludePath2: as above
  postbuild: "$ZSTACKDIR$\Projects\tools\OTA\OtaConverter\Release\OtaConverter.exe" "RouterEB - OTAClient\Exe\RouterEB-OTAClient.sim" -o"RouterEB - OTAClient\Exe" -t0x1234 -m0x5678 -v0001ABCD -pCC2530DB
  XLINK.XclFile: $ZSTACKDIR$\Projects\zstack\Tools\CC2530DB\ota.xcl
  group App
    ../Source/: OSAL_WaterCounter.c zcl_watercounter.c zcl_watercounter.h zcl_watercounter_data.c
  group BDB
    $ZSTACKDIR$/Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group GP
    $ZSTACKDIR$/Components/stack/GP/: cGP_stub.h dGP_stub.h gp_common.c gp_common.h gp_interface.h gp_proxyTbl.c
  group HAL/Common
    ../hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530DEV/Config
    ../hal/target/CC2530DEV/: hal_board_cfg.h
  group HAL/Target/CC2530DEV/Drivers
    ../hal/target/CC2530DEV/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_ota.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530DEV/Includes
    ../hal/target/CC2530DEV/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_ota.h hal_types.h
  group MAC/High Level
    $ZSTACKDIR$/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    $ZSTACKDIR$/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    $ZSTACKDIR$/Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    $ZSTACKDIR$/Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    $ZSTACKDIR$/Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    $ZSTACKDIR$/Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    $ZSTACKDIR$/Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    $ZSTACKDIR$/Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    $ZSTACKDIR$/Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    $ZSTACKDIR$/Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    $ZSTACKDIR$/Components/stack/af/: AF.c AF.h
    $ZSTACKDIR$/Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_general.c zcl_general.h zcl_green_power.c zcl_green_power.h zcl_ota.c zcl_ota.h
    $ZSTACKDIR$/Projects/zstack/HomeAutomation/Source/: zcl_ha.c zcl_ha.h
  group Security
    $ZSTACKDIR$/Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    $ZSTACKDIR$/Components/services/saddr/: saddr.c saddr.h
  group Tools
    $ZSTACKDIR$/Projects/zstack/Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg ota.xcl
  group ZDO
    $ZSTACKDIR$/Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    $ZSTACKDIR$/Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    $ZSTACKDIR$/Components/zmac/: ZMAC.h
  group ZMain
    $ZSTACKDIR$/Projects/zstack/ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
